# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\user;..\ml_libs;..\code;..\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c isr.c
  group code
    ../code/: motor.c motor.h pid.c pid.h gray_track.c gray_track.h LB.c LB.h Key.c Key.h filter.c filter.h
    ./: LED.c LED.h
  group sys
    ../sys/: system_stm32f10x.h system_stm32f10x.c stm32f10x.h startup_stm32f10x_md.s core_cmInstr.h core_cmFunc.h core_cm3.h
  group ml_libs
    ../ml_libs/: headfile.h ml_mpu6050.h ml_mpu6050.c ml_i2c.c ml_i2c.h ml_oled.c ml_oled.h
    ../ML_LIBS/: ml_gpio.c ml_gpio.h ml_delay.c ml_delay.h ml_nvic.h ml_nvic.c ml_pwm.c ml_pwm.h ml_tim.c ml_tim.h ml_uart.c ml_uart.h ml_oled_font.h ml_adc.c ml_adc.h ml_exti.c ml_exti.h
